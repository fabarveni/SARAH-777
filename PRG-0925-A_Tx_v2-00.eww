<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\PRG-0925-A_Tx_v2-00.ewp</path>
  </project>
  <batchBuild/>
</workspace>


