# IAR project PRG-0925-A_Tx_v2-00.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F1026A RL78 - R5F1026A
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 256
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkr5f1026a.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  General.GenStackSize: 128
  ICCRL78.CCDefines: NDEBUG
  ICCRL78.CCIncludePath2: applilet3_src; user_src
  ARL78.AsmIncludePath: applilet3_src; user_src
  group applilet3_src
    applilet3_src/: r_main.c
  group user_src
    user_src/: CC110L.h Hardware_Profile.h
